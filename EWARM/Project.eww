<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\dji_driver_v2.0.ewp</path>
  </project>
  <batchBuild />
</workspace>
